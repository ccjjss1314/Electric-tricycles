# Keil uVision project ADC_DMA.uvprojx, settings and files
target N32g430 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_DMA +hex
  AfterMake: fromelf --bin --output=.\bin\ADC_DMA.bin .\Objects\ADC_DMA.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: ..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32g430_std_periph_driver\inc;..\inc;..\..\bsp\inc;..\..\my\inc;..\..\..\FreeRtos\include;..\..\..\User;..\..\..\FreeRtos\port\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../firmware/CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../../../firmware/CMSIS/device/: system_n32g430.c
  group FWLB
    ../../../firmware/n32g430_std_periph_driver/src/: n32g430_adc.c misc.c n32g430_dma.c n32g430_flash.c n32g430_gpio.c n32g430_rcc.c n32g430_spi.c n32g430_usart.c n32g430_tim.c n32g430_rtc.c n32g430_pwr.c
    ../src/: n32g430_exti.c
  group USER
    ../src/: main.c adc.c n32g430_it.c spi.c System_Init.c usart.c tim.c dma.c
    ../../bsp/src/: log.c
  group DOC
    ../: readme.txt
  group MY
    ../../my/src/: BufferManage.c LoopList.c flash_helper.c stmflash.c
  group FreeRTOS/src
    ../../../FreeRtos/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../../FreeRtos/port/MemMang/: heap_4.c
    ../../../FreeRtos/port/RVDS/ARM_CM4F/: port.c
